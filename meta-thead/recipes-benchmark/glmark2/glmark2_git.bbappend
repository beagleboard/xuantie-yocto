
SRC_URI = " \
    git://git@gitee.com/t-head-linux/glmark2.git;protocol=https;branch=master \
    file://0001-fix-dispmanx-build.patch \
    file://0002-run-dispmanx-fullscreen.patch \
    file://0001-libmatrix-Include-missing-utility-header.patch \
    "
