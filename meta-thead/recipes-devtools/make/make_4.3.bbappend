
# fix error in thead-yocto
# TODO. check posix-spawn with team:OS-tools
EXTRA_OECONF += "--disable-posix-spawn"
