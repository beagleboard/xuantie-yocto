do_install:append() {
    rm -f ${D}/usr/libexec/colord
}
