IMAGE_INSTALL += " op-tee "

inherit core-image
