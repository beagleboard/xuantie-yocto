COMPATIBLE_MACHINE:append = "|qemuriscv32"
