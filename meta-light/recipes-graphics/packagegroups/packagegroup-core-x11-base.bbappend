RDEPENDS:${PN}:remove = "matchbox-terminal matchbox-wm mini-x-session"
