RDEPENDS:${PN}-utils:remove = "${VIRTUAL-RUNTIME_graphical_init_manager}"
