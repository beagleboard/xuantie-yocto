OS_RELEASE_FIELDS:append = " BUILD_ID HOME_URL "
HOME_URL = "https://occ.t-head.cn/"
