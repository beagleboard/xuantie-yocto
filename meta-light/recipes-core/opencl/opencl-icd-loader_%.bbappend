FILES:${PN}:append = " ${libdir}/libOpenCL.so.1 "
