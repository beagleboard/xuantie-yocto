EXTRA_OECONF:append_d1 = " \
    --with-versioned=no \
"
