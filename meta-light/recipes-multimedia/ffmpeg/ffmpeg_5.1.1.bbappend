FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-compile-cpu.c-not-find-sysctl.h-file-error.patch"

