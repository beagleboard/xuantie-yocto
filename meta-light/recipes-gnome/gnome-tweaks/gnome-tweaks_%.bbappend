FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
  
# SRC_URI:append = " file://0001-Port-to-libhandy-1.patch"
